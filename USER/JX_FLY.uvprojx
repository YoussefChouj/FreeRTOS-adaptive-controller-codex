# Keil uVision project JX_FLY.uvprojx, settings and files
target JX_FLY (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JX_FLY +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\USER;..\stm32_lib;..\TASK;..\Global_file;..\BSP;..\API;..\firmware;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\JX_FLY.sct
  group NOTE
    ../NOTE/: readme.txt pcb.txt
  group USER
    ./: main.c retarget.c fault_capture.c fault_capture.h
  group TASK
    ../TASK/: led.c RemoterTask.c StabilizerTask.c stm32f4xx_it.c systemmonitor_task.c AutoflyTask.c send_data.c
  group API
    ../API/: bmi088_driver.c delay.c imu_update.c pid.c mrac.c mrac_math.c xy_ctrl.c wfb_traj.c wfb_safety.c prearm.c land_gate.c traj_shape.c fw_health.c wfb_prim.c wfb_glue.c wfb_prog.c sysid.c gyro_filter.c ekf.c controller.c ekf_of.c thrust_estimators.c calib.c subscribe.c rc_input.c flight_fsm.c time_estimate.c sys.c Ano_OF.c tf_mini_plus.c SINS.c Accel_Calibartion.c Filter.c GPS.c fw_identity.c fw_identity.h send_prof.c send_prof.h
    ./: ADC.c ADC.h
  group BSP
    ../BSP/: BSP.c pwm.c rpm.c spi.c usart1.c usart4.c usart2.c usart6.c usart5.c usart3.c
  group firmware
    ../firmware/: build_identity.c command_protocol.c platform_registry.c platform_registry_gen.c rtos_observability.c
  group GOLBAL_FILE
    ../Global_file/: global_declare.c globaluse_basic_function.c creat_task.h algorithm.c
  group stm32_lib
    ../stm32_lib/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
